# Keil uVision project DOKATOUCH_a.uvprojx, settings and files
target DOKATOUCH_a (5060750::V5.06 update 6 (build 750)::.\ARM_Compiler_5.06u6)
  device: STM32L071V8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DOKATOUCH_a
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L071xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Application/User
    ./: myIwdg.c myllUart.c AZD_KRD_Message.c mySub.c myWait16MHz.c myCrc16.c KanaPilot_BH.c BackHoe_Drive.c KanaPilot_PcCom.c KanaPilot_SensCom.c
    ../Src/: main.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_ll_crc.c stm32l0xx_ll_i2c.c stm32l0xx_ll_spi.c stm32l0xx_ll_pwr.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_rcc.c
software components: CMSIS:CORE 5.3.0
